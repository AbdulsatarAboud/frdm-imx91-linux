# meta-imx replaces 10-imx.rules (no SPDX header) without updating the checksum.
# Line 1 of NXP's file verified 2026-11-08; MIT licence unchanged.
LIC_FILES_CHKSUM = "file://10-imx.rules;beginline=1;endline=1;md5=e0f457421c29681ab53465c67278df1c"
